** SPICE netlist generated by bigspicy.py at Sat Dec 10 06:17:51 2022 UTC
.SUBCKT iiitb_jc
+ VGND VPWR clk reset q.0 q.1 q.2 q.3 q.4 q.5 q.6 q.7
** replacing FILLER_0_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_0_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_0_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_35 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_35/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_35/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_35/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_35/VPB =>[signal: VPWR w=1]]']]
FILLER_0_35 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_47 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_0_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_57 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_0_61 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_66 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_9/VPB =>[signal: VPWR w=1]]']]
FILLER_0_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_29/VPB =>[signal: VPWR w=1]]']]
FILLER_10_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_10_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_41/VPB =>[signal: VPWR w=1]]']]
FILLER_10_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_53/VPB =>[signal: VPWR w=1]]']]
FILLER_10_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_10_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_9/VPB =>[signal: VPWR w=1]]']]
FILLER_10_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_11_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_11_29 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_11_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_11_37 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_11_42 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_42/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_42/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_42/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_42/VPB =>[signal: VPWR w=1]]']]
FILLER_11_42 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_11_57 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_11_61 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_11_66 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_11_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_9/VPB =>[signal: VPWR w=1]]']]
FILLER_11_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_15/VPB =>[signal: VPWR w=1]]']]
FILLER_1_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_27/VPB =>[signal: VPWR w=1]]']]
FILLER_1_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_3/VPB =>[signal: VPWR w=1]]']]
FILLER_1_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_39/VPB =>[signal: VPWR w=1]]']]
FILLER_1_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_1_57 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_61 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_1_66 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_2_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_2_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_29/VPB =>[signal: VPWR w=1]]']]
FILLER_2_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_2_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_41/VPB =>[signal: VPWR w=1]]']]
FILLER_2_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_53/VPB =>[signal: VPWR w=1]]']]
FILLER_2_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_2_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_9/VPB =>[signal: VPWR w=1]]']]
FILLER_2_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_15/VPB =>[signal: VPWR w=1]]']]
FILLER_3_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_27 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_3_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_3/VPB =>[signal: VPWR w=1]]']]
FILLER_3_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_49 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_3_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_3_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_3_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_4_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_4_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_4_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_4_51 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_51/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_51/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_51/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_51/VPB =>[signal: VPWR w=1]]']]
FILLER_4_51 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_63 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_63_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_63_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_4_67 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_5_3 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_5_30 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_30_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_30_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_5_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_5_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_5_9 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_6_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_6_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_6_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_6_51 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_51/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_51/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_51/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_51/VPB =>[signal: VPWR w=1]]']]
FILLER_6_51 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_63 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_63_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_63_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_6_67 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_7_11 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_7_17 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_3 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_7_43 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_43/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_43/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_43/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_43/VPB =>[signal: VPWR w=1]]']]
FILLER_7_43 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_7_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_7_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_8_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_15/VPB =>[signal: VPWR w=1]]']]
FILLER_8_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_29/VPB =>[signal: VPWR w=1]]']]
FILLER_8_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_3/VPB =>[signal: VPWR w=1]]']]
FILLER_8_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_41/VPB =>[signal: VPWR w=1]]']]
FILLER_8_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_53/VPB =>[signal: VPWR w=1]]']]
FILLER_8_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_9_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_15/VPB =>[signal: VPWR w=1]]']]
FILLER_9_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_27/VPB =>[signal: VPWR w=1]]']]
FILLER_9_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_3/VPB =>[signal: VPWR w=1]]']]
FILLER_9_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_39/VPB =>[signal: VPWR w=1]]']]
FILLER_9_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_57 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_61 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_66 with the contents of sky130_fd_sc_hd__fill_2

** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_24 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_25 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_26 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_27 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_28 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_29 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_30 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_31 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_32 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_33 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_34 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_35 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_36 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_37 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _1_ with the contents of sky130_fd_sc_hd__clkinv_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__1__0 _0_ net10 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__1__1 VPWR net10 _0_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__1__2 _0_ net10 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__1__3 VGND net10 _0_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__1__4 _0_ net10 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _2_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__2__0 _2__a_1270_413# _2__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__2__1 VPWR _2__a_543_47# _2__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__2__2 VGND _2__a_543_47# _2__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__2__3 VGND _0_ _2__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__2__4 _2__a_1108_47# _2__a_193_47# _2__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__2__5 VGND _2__a_1283_21# net3 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__2__6 _2__a_1217_47# _2__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__2__7 _2__a_448_47# _2__a_27_47# _2__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__2__8 _2__a_448_47# _2__a_193_47# _2__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__2__9 _2__a_543_47# _2__a_193_47# _2__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__2__10 _2__a_1108_47# _2__a_27_47# _2__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__2__11 _2__a_1462_47# _2__a_1108_47# _2__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__2__12 _2__a_543_47# _2__a_27_47# _2__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__2__13 _2__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__2__14 _2__a_761_289# _2__a_193_47# _2__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__2__15 VPWR net2 _2__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__2__16 VGND _2__a_27_47# _2__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__2__17 _2__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__2__18 _2__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__2__19 VPWR _2__a_1283_21# net3 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__2__20 VPWR _2__a_27_47# _2__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__2__21 _2__a_1283_21# _2__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__2__22 VGND net2 _2__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__2__23 VPWR _0_ _2__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__2__24 _2__a_651_413# _2__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__2__25 _2__a_761_289# _2__a_27_47# _2__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__2__26 VPWR net2 _2__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__2__27 _2__a_639_47# _2__a_761_289# _2__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _3_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__3__0 _3__a_1270_413# _3__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__3__1 VPWR _3__a_543_47# _3__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__3__2 VGND _3__a_543_47# _3__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__3__3 VGND net3 _3__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__3__4 _3__a_1108_47# _3__a_193_47# _3__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__3__5 VGND _3__a_1283_21# net4 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__3__6 _3__a_1217_47# _3__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__3__7 _3__a_448_47# _3__a_27_47# _3__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__3__8 _3__a_448_47# _3__a_193_47# _3__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__3__9 _3__a_543_47# _3__a_193_47# _3__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__3__10 _3__a_1108_47# _3__a_27_47# _3__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__3__11 _3__a_1462_47# _3__a_1108_47# _3__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__3__12 _3__a_543_47# _3__a_27_47# _3__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__3__13 _3__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__3__14 _3__a_761_289# _3__a_193_47# _3__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__3__15 VPWR net2 _3__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__3__16 VGND _3__a_27_47# _3__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__3__17 _3__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__3__18 _3__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__3__19 VPWR _3__a_1283_21# net4 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__3__20 VPWR _3__a_27_47# _3__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__3__21 _3__a_1283_21# _3__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__3__22 VGND net2 _3__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__3__23 VPWR net3 _3__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__3__24 _3__a_651_413# _3__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__3__25 _3__a_761_289# _3__a_27_47# _3__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__3__26 VPWR net2 _3__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__3__27 _3__a_639_47# _3__a_761_289# _3__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _4_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__4__0 _4__a_1270_413# _4__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__4__1 VPWR _4__a_543_47# _4__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__4__2 VGND _4__a_543_47# _4__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__4__3 VGND net4 _4__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__4__4 _4__a_1108_47# _4__a_193_47# _4__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__4__5 VGND _4__a_1283_21# net5 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__4__6 _4__a_1217_47# _4__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__4__7 _4__a_448_47# _4__a_27_47# _4__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__4__8 _4__a_448_47# _4__a_193_47# _4__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__4__9 _4__a_543_47# _4__a_193_47# _4__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__4__10 _4__a_1108_47# _4__a_27_47# _4__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__4__11 _4__a_1462_47# _4__a_1108_47# _4__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__4__12 _4__a_543_47# _4__a_27_47# _4__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__4__13 _4__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__4__14 _4__a_761_289# _4__a_193_47# _4__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__4__15 VPWR net2 _4__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__4__16 VGND _4__a_27_47# _4__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__4__17 _4__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__4__18 _4__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__4__19 VPWR _4__a_1283_21# net5 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__4__20 VPWR _4__a_27_47# _4__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__4__21 _4__a_1283_21# _4__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__4__22 VGND net2 _4__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__4__23 VPWR net4 _4__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__4__24 _4__a_651_413# _4__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__4__25 _4__a_761_289# _4__a_27_47# _4__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__4__26 VPWR net2 _4__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__4__27 _4__a_639_47# _4__a_761_289# _4__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _5_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__5__0 _5__a_1270_413# _5__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__5__1 VPWR _5__a_543_47# _5__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__5__2 VGND _5__a_543_47# _5__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__5__3 VGND net5 _5__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__5__4 _5__a_1108_47# _5__a_193_47# _5__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__5__5 VGND _5__a_1283_21# net6 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__5__6 _5__a_1217_47# _5__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__5__7 _5__a_448_47# _5__a_27_47# _5__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__5__8 _5__a_448_47# _5__a_193_47# _5__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__5__9 _5__a_543_47# _5__a_193_47# _5__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__5__10 _5__a_1108_47# _5__a_27_47# _5__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__5__11 _5__a_1462_47# _5__a_1108_47# _5__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__5__12 _5__a_543_47# _5__a_27_47# _5__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__5__13 _5__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__5__14 _5__a_761_289# _5__a_193_47# _5__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__5__15 VPWR net2 _5__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__5__16 VGND _5__a_27_47# _5__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__5__17 _5__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__5__18 _5__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__5__19 VPWR _5__a_1283_21# net6 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__5__20 VPWR _5__a_27_47# _5__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__5__21 _5__a_1283_21# _5__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__5__22 VGND net2 _5__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__5__23 VPWR net5 _5__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__5__24 _5__a_651_413# _5__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__5__25 _5__a_761_289# _5__a_27_47# _5__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__5__26 VPWR net2 _5__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__5__27 _5__a_639_47# _5__a_761_289# _5__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _6_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__6__0 _6__a_1270_413# _6__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__6__1 VPWR _6__a_543_47# _6__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__6__2 VGND _6__a_543_47# _6__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__6__3 VGND net6 _6__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__6__4 _6__a_1108_47# _6__a_193_47# _6__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__6__5 VGND _6__a_1283_21# net7 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__6__6 _6__a_1217_47# _6__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__6__7 _6__a_448_47# _6__a_27_47# _6__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__6__8 _6__a_448_47# _6__a_193_47# _6__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__6__9 _6__a_543_47# _6__a_193_47# _6__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__6__10 _6__a_1108_47# _6__a_27_47# _6__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__6__11 _6__a_1462_47# _6__a_1108_47# _6__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__6__12 _6__a_543_47# _6__a_27_47# _6__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__6__13 _6__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__6__14 _6__a_761_289# _6__a_193_47# _6__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__6__15 VPWR net2 _6__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__6__16 VGND _6__a_27_47# _6__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__6__17 _6__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__6__18 _6__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__6__19 VPWR _6__a_1283_21# net7 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__6__20 VPWR _6__a_27_47# _6__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__6__21 _6__a_1283_21# _6__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__6__22 VGND net2 _6__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__6__23 VPWR net6 _6__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__6__24 _6__a_651_413# _6__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__6__25 _6__a_761_289# _6__a_27_47# _6__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__6__26 VPWR net2 _6__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__6__27 _6__a_639_47# _6__a_761_289# _6__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _7_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__7__0 _7__a_1270_413# _7__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__7__1 VPWR _7__a_543_47# _7__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__7__2 VGND _7__a_543_47# _7__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__7__3 VGND net7 _7__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__7__4 _7__a_1108_47# _7__a_193_47# _7__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__7__5 VGND _7__a_1283_21# net8 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__7__6 _7__a_1217_47# _7__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__7__7 _7__a_448_47# _7__a_27_47# _7__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__7__8 _7__a_448_47# _7__a_193_47# _7__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__7__9 _7__a_543_47# _7__a_193_47# _7__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__7__10 _7__a_1108_47# _7__a_27_47# _7__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__7__11 _7__a_1462_47# _7__a_1108_47# _7__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__7__12 _7__a_543_47# _7__a_27_47# _7__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__7__13 _7__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__7__14 _7__a_761_289# _7__a_193_47# _7__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__7__15 VPWR net2 _7__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__7__16 VGND _7__a_27_47# _7__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__7__17 _7__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__7__18 _7__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__7__19 VPWR _7__a_1283_21# net8 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__7__20 VPWR _7__a_27_47# _7__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__7__21 _7__a_1283_21# _7__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__7__22 VGND net2 _7__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__7__23 VPWR net7 _7__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__7__24 _7__a_651_413# _7__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__7__25 _7__a_761_289# _7__a_27_47# _7__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__7__26 VPWR net2 _7__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__7__27 _7__a_639_47# _7__a_761_289# _7__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _8_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__8__0 _8__a_1270_413# _8__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__8__1 VPWR _8__a_543_47# _8__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__8__2 VGND _8__a_543_47# _8__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__8__3 VGND net8 _8__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__8__4 _8__a_1108_47# _8__a_193_47# _8__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__8__5 VGND _8__a_1283_21# net9 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__8__6 _8__a_1217_47# _8__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__8__7 _8__a_448_47# _8__a_27_47# _8__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__8__8 _8__a_448_47# _8__a_193_47# _8__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__8__9 _8__a_543_47# _8__a_193_47# _8__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__8__10 _8__a_1108_47# _8__a_27_47# _8__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__8__11 _8__a_1462_47# _8__a_1108_47# _8__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__8__12 _8__a_543_47# _8__a_27_47# _8__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__8__13 _8__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__8__14 _8__a_761_289# _8__a_193_47# _8__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__8__15 VPWR net2 _8__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__8__16 VGND _8__a_27_47# _8__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__8__17 _8__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__8__18 _8__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__8__19 VPWR _8__a_1283_21# net9 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__8__20 VPWR _8__a_27_47# _8__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__8__21 _8__a_1283_21# _8__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__8__22 VGND net2 _8__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__8__23 VPWR net8 _8__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__8__24 _8__a_651_413# _8__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__8__25 _8__a_761_289# _8__a_27_47# _8__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__8__26 VPWR net2 _8__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__8__27 _8__a_639_47# _8__a_761_289# _8__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _9_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__9__0 _9__a_1270_413# _9__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__9__1 VPWR _9__a_543_47# _9__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__9__2 VGND _9__a_543_47# _9__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__9__3 VGND net9 _9__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__9__4 _9__a_1108_47# _9__a_193_47# _9__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__9__5 VGND _9__a_1283_21# net10 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__9__6 _9__a_1217_47# _9__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__9__7 _9__a_448_47# _9__a_27_47# _9__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__9__8 _9__a_448_47# _9__a_193_47# _9__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__9__9 _9__a_543_47# _9__a_193_47# _9__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__9__10 _9__a_1108_47# _9__a_27_47# _9__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__9__11 _9__a_1462_47# _9__a_1108_47# _9__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__9__12 _9__a_543_47# _9__a_27_47# _9__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__9__13 _9__a_805_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__9__14 _9__a_761_289# _9__a_193_47# _9__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__9__15 VPWR net2 _9__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__9__16 VGND _9__a_27_47# _9__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__9__17 _9__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__9__18 _9__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__9__19 VPWR _9__a_1283_21# net10 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__9__20 VPWR _9__a_27_47# _9__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__9__21 _9__a_1283_21# _9__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__9__22 VGND net2 _9__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__9__23 VPWR net9 _9__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__9__24 _9__a_651_413# _9__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__9__25 _9__a_761_289# _9__a_27_47# _9__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__9__26 VPWR net2 _9__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__9__27 _9__a_639_47# _9__a_761_289# _9__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_input1_0 input1_a_27_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_input1_1 input1_a_27_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X_input1_2 net1 input1_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 VPWR input1_a_27_47# net1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X_input1_4 net1 input1_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input1_5 VGND input1_a_27_47# net1 VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input2_0 net2 input2_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input2_1 input2_a_27_47# reset VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input2_2 VGND input2_a_27_47# net2 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 net2 input2_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_input2_4 VPWR input2_a_27_47# net2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input2_5 input2_a_27_47# reset VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output10 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output10_0 q.7 output10_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output10_1 output10_a_27_47# net10 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output10_2 VGND output10_a_27_47# q.7 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output10_3 q.7 output10_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output10_4 VPWR output10_a_27_47# q.7 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output10_5 output10_a_27_47# net10 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output3 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output3_0 q.0 output3_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output3_1 output3_a_27_47# net3 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output3_2 VGND output3_a_27_47# q.0 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output3_3 q.0 output3_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output3_4 VPWR output3_a_27_47# q.0 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output3_5 output3_a_27_47# net3 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output4 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output4_0 q.1 output4_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output4_1 output4_a_27_47# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output4_2 VGND output4_a_27_47# q.1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output4_3 q.1 output4_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output4_4 VPWR output4_a_27_47# q.1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output4_5 output4_a_27_47# net4 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output5 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output5_0 q.2 output5_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output5_1 output5_a_27_47# net5 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output5_2 VGND output5_a_27_47# q.2 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output5_3 q.2 output5_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output5_4 VPWR output5_a_27_47# q.2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output5_5 output5_a_27_47# net5 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output6 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output6_0 q.3 output6_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output6_1 output6_a_27_47# net6 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output6_2 VGND output6_a_27_47# q.3 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output6_3 q.3 output6_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output6_4 VPWR output6_a_27_47# q.3 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output6_5 output6_a_27_47# net6 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output7 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output7_0 q.4 output7_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output7_1 output7_a_27_47# net7 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output7_2 VGND output7_a_27_47# q.4 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output7_3 q.4 output7_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output7_4 VPWR output7_a_27_47# q.4 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output7_5 output7_a_27_47# net7 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output8 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output8_0 q.5 output8_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output8_1 output8_a_27_47# net8 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output8_2 VGND output8_a_27_47# q.5 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output8_3 q.5 output8_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output8_4 VPWR output8_a_27_47# q.5 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output8_5 output8_a_27_47# net8 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output9 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output9_0 q.6 output9_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output9_1 output9_a_27_47# net9 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output9_2 VGND output9_a_27_47# q.6 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output9_3 q.6 output9_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output9_4 VPWR output9_a_27_47# q.6 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output9_5 output9_a_27_47# net9 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
